# Keil uVision project STM32F407_HSE_TEST1.uvprojx, settings and files
target STM32F407_HSE_TEST1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407_HSE_TEST1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c define: USE_FULL_LL_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1U
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Drivers\CMSIS\DSP\Include;..\Drivers\CMSIS\DSP\Source;..\Drivers\CMSIS\DSP\Source\BasicMathFunctions;..\Drivers\CMSIS\DSP\Source\CommonTables;..\Drivers\CMSIS\DSP\Source\ComplexMathFunctions;..\Drivers\CMSIS\DSP\Source\ControllerFunctions;..\Drivers\CMSIS\DSP\Source\FastMathFunctions;..\Drivers\CMSIS\DSP\Source\FilteringFunctions;..\Drivers\CMSIS\DSP\Source\MatrixFunctions;..\Drivers\CMSIS\DSP\Source\StatisticsFunctions;..\Drivers\CMSIS\DSP\Source\SupportFunctions;..\Drivers\CMSIS\DSP\Source\TransformFunctions;..\Drivers\CMSIS\Lib\ARM;..\Drivers\CMSIS\Lib\GCC;..\Middlewares\FreeRTOS-Kernel;..\Middlewares\FreeRTOS-Kernel\include;..\Middlewares\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: STM32F407_HSE_TEST1\STM32F407_HSE_TEST1.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c l6474_drvr.c kinematics.c robot_behavior_routine.c irq_process.c spi_gpio.c board_hw_config.c usartx_communication.c fifo_routine.c odometry_task.c usartx_timeout.c hl_old.c terminal_task.c dynamixel_ax.c dynamixel_mx.c dynamixel_protocol10.c maxon.c terminal.c terminal_cmd_handler.c stepper.c rc_servo.c gpio_board_config.c gpio_robot_config.c experimental_task_1.c experimental_task_2.c freertos_routine_plug.c hl_new.c ws2812b.c odometry.c bus_device_def.c button.c button_task.c game_task.c h_bridge.c grub_pile_task.c flags.c release_pile_task.c task_DC.c encoder_board_drvr.c serial_protocol.c DC_Motor.c task_DC1.c task_DC2.c task_DC0.c task_sort.c task_sort_optimize.c task_zero_state.c task_gripper_calibration.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver*LL
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
  group DSP
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
    ../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
  group Middlewares/FreeRTOS-Kernel
    ../Middlewares/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.6.0
